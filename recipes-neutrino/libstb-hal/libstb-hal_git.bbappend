FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

include ${FLAVOUR}.inc

