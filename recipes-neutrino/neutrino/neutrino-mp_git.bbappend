EXTRA_OECONF:append += "--with-boxtype=armbox \
                        --with-boxmodel=hd60 \
"
